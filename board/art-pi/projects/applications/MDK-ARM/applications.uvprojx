# Keil uVision project applications.uvprojx, settings and files
target applications (6240000::V6.24::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: applications
  AfterMake: fromelf --bin !L --output build/bin/application.bin
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=5 v6LangP=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H750xx, CY_USING_HAL, CYBSP_WIFI_CAPABLE
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/source/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-freertos-integration/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/inc/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/src/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/src/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/resources/resource_imp/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/src/bus_protocols/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/arpa;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/net;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/sys;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/stdc;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43438/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/COMPONENT_FREERTOS/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43438;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/inc;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/resources/resource_imp;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include;..\Bsp\Components\ili9481;..\Bsp\Components\ft5xx6;..\Bsp\Components\sdram;..\Bsp\Components\st7789;..\App\ui;..\FreeRTOS_CLI;..\Bsp\Components\ap6212\firmware\COMPONENT_43438;..\Bsp\Components\ap6212\clm\COMPONENT_43438;..\Bsp\Components\ap6212\nvram\COMPONENT_43438\COMPONENT_AW-CU427-P;..\MyDrivers\hw_iic;..\App\ui;..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI
  asm include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/source/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-freertos-integration/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/inc/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/src/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/src/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/resources/resource_imp/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/src/bus_protocols/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/arpa;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/net;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/posix/sys;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/compat/stdc;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43438/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include/COMPONENT_FREERTOS/;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/hal/include;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Inc;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Inc;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/core-lib/include;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/COMPONENT_43438;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/inc;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/resources/resource_imp;../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/include
  memory RVCT4: ROM 0x90000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c crc.c dcmi.c dma.c dma2d.c eth.c fdcan.c fmc.c i2c.c ltdc.c sdmmc.c spi.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c wifi_task.c lvgl_port.cpp
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group Middlewares/Connectivity/Wireless/Wifi/network-interface/LWIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-network-interface-integration/source/: cy_ethernetif.c cy_lwip_dhcp_server.c cy_network_mw_core.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/lwip-freertos-integration/arch/: sys_arch.c
  group Middlewares/Connectivity/Wireless/Wifi/wifi-host-driver
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/src/bus_protocols/: whd_bus.c whd_bus_common.c whd_bus_sdio_protocol.c whd_bus_spi_protocol.c whd_bus_emusbh_impl.c whd_bus_usb_protocol.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/src/: whd_ap.c whd_buffer_api.c whd_cdc_bdc.c whd_chip.c whd_chip_constants.c whd_clm.c whd_debug.c whd_events.c whd_logging.c whd_management.c whd_network_if.c whd_proto.c whd_resource_if.c whd_sdpcm.c whd_thread.c whd_utils.c whd_wifi.c whd_wifi_api.c whd_wifi_p2p.c whd_commonring.c whd_flowring.c whd_ring.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/COMPONENT_WIFI5/resources/resource_imp/: whd_resources.c
  group Middlewares/Connectivity/Wireless/Wifi/wcm/WCM
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-connection-manager/source/: cy_wcm.c
  group Middlewares/Connectivity/Wireless/Wifi/connectivity-utilities
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_log/: cy_log.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/JSON_parser/: cy_json_parser.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/linked_list/: cy_linked_list.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/cy_string/: cy_string_utils.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/: cy_nw_helper_common.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/connectivity-utilities/network/COMPONENT_LWIP/: cy_nw_helper.c
  group Middlewares/Connectivity/Wireless/Wifi/whd-bsp-integration
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/: cybsp_wifi.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/whd-bsp-integration/COMPONENT_LWIP/: cy_network_buffer_lwip.c
  group Middlewares/Connectivity/Wireless/Wifi/LwIP
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/LwIP/src/netif/: ethernet.c
  group Middlewares/Connectivity/Documentation
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/wifi-host-driver/: generated_mac_address.txt
  group Middlewares/Connectivity/Wireless/Platform/pal
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/common/Src/: cyhal_system.c wifi_bt_if.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/targets/TARGET_STM32/Src/: stm32_cyhal_gpio.c stm32_cyhal_lptimer.c stm32_cyhal_sdio.c stm32_cyhal_spi.c stm32_cyhal_trng.c stm32_cyhal_uart.c stm32_cyhal_syspm.c
  group Middlewares/Connectivity/Wireless/Platform/device/CYW43438
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/btstack-integration/COMPONENT_HCI-UART/firmware/COMPONENT_43438/COMPONENT_AW-CU427-P/: w_bt_firmware_controller.c
  group Middlewares/Connectivity/Wireless/Platform/abstraction-rtos/FreeRTOS
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/COMPONENT_FREERTOS/: cyabs_freertos_helpers.c cyabs_rtos_freertos.c cyabs_freertos_common.c
    ../Middlewares/Third_Party/Infineon_Wireless_Connectivity/pal/abstraction-rtos/source/: cy_worker_thread.c
  group Bsp
    ../Bsp/Components/sdram/: sdram.c
    ../Bsp/Components/st7789/: st7789.c
    ../Bsp/Components/ili9481/: ili9481.c
    ../Bsp/Components/ft5xx6/: Ft5xx6.cpp
    ../Bsp/Components/ap6212/clm/COMPONENT_43438/: 43438A1_clm_blob.c 43438A1-mfgtest_clm_blob.c
    ../Bsp/Components/ap6212/firmware/COMPONENT_43438/: 43438A1_bin.c 43438A1-mfgtest_bin.c
  group MyDrivers
    ../MyDrivers/hw_iic/: hw_iic.cpp
    ../FreeRTOS_CLI/: app_cli.c cli_commands.c
  group Application/ui
    ../App/ui/: ui_helpers.c ui.c
    ../App/ui/components/: ui_comp_hook.c
    ../App/ui/fonts/: ui_font_Big_Number.c ui_font_Bold_Font.c
    ../App/ui/images/: ui_img_img_arrow_right_png.c ui_img_img_bg_1_png.c ui_img_img_btc_png.c ui_img_img_card_png.c ui_img_img_eth_png.c ui_img_img_pos_png.c ui_img_img_qr_png.c ui_img_img_xrp_png.c ui_img_ok_png.c
    ../App/ui/screens/: ui_POS_S1.c ui_POS_S2.c ui_POS_S3.c ui_POS_S4.c ui_POS_S5.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1, LVGL:Demos:Assets 9.3.0, LVGL:Demos:Benchmark 9.3.0, LVGL:Demos:Widgets 9.3.0, LVGL:Display 9.3.0, LVGL:Essential 9.3.0
